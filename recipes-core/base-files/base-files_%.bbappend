FILESEXTRAPATHS_prepend_udooneo := "${THISDIR}/${PN}:"
