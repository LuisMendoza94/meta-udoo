PACKAGECONFIG_append_udooneo += "etnaviv"
